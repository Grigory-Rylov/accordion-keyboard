## config/boards/shields/accordion_keyboard/Kconfig.shield
```kconfig
config SHIELD_ACCORDION_KEYBOARD
    def_bool $(shields_list_contains,accordion_keyboard)
```
